options:
  parameters:
    generate_options: no_gui
    id: hd_tx_hackrf_wxkj
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: dac_rate
  id: variable
  parameters:
    value: 128e6
  states: {}
- name: fm_max_dev
  id: variable
  parameters:
    value: 80e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 103.7e6
  states: {}
- name: input_gain
  id: variable
  parameters:
    comment: |-
      FM Stereo &-RDS TX  Mod. index % : 
      42,5% (L+R) 
      42,5% (L-R) DSB SC
      10% 19khz tone
      5%   RDS BPSK DSB SC
    value: '0.425'
  states: {}
- name: max_dev
  id: variable
  parameters:
    value: 192e3
  states: {}
- name: outbuffer
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: quad_rate_0
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: 2*math.pi*max_dev/quad_rate
  states: {}
- name: usrp_interp
  id: variable
  parameters:
    value: '500'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: int(dac_rate/usrp_interp)
  states: {}
- name: audio_source_0_0
  id: audio_source
  parameters:
    device_name: WDUS
    num_outputs: '2'
    ok_to_block: 'False'
    samp_rate: '192000'
  states: {}
- name: audio_source_0_0_0
  id: audio_source
  parameters:
    device_name: WDNR
    num_outputs: '2'
    samp_rate: '192000'
  states: {}
- name: audio_source_0_0_0_0
  id: audio_source
  parameters:
    device_name: SmartFM
    num_outputs: '2'
    ok_to_block: 'False'
    samp_rate: '192000'
  states: {}
- name: audio_source_0_0_0_0_0_0
  id: audio_source
  parameters:
    device_name: WPSZ
    num_outputs: '2'
    ok_to_block: 'False'
    samp_rate: '192000'
  states: {}
- name: audio_source_0_0_1
  id: audio_source
  parameters:
    device_name: WXKJ
    num_outputs: '2'
    ok_to_block: 'False'
    samp_rate: '192000'
  states: {}
- name: audio_source_1
  id: audio_source
  parameters:
    device_name: MPX
    samp_rate: '192000'
  states: {}
- name: audio_source_1_0
  id: audio_source
  parameters:
    device_name: RDS_Injection
    samp_rate: '192000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(audio_rate * 4.458)
    type: float
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '2160'
    n: '4096'
    offset: '0'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.00750'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.750'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
    vlen: '4608'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: complex
    vlen: '2048'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[math.sin(math.pi / 2 * i / 112) for i in range(112)] + [1] * (2048-112) + [math.cos(math.pi / 2 * i / 112) for i in range(112)]'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(2048)
  states: {}
- name: gr_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    maxoutbuf: outbuffer
    sensitivity: 2*math.pi*fm_max_dev/usrp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 192000/44100
    type: float
  states: {}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 192000/44100
    type: float
  states: {}
- name: mmse_resampler_xx_0_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 192000/44100
    type: float
  states: {}
- name: mmse_resampler_xx_0_0_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 192000/44100
    type: float
  states: {}
- name: mmse_resampler_xx_0_0_0_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 192000/44100
    type: float
  states: {}
- name: mmse_resampler_xx_0_0_0_1
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 192000/44100
    type: float
  states: {}
- name: mmse_resampler_xx_0_1
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 192000/44100
    type: float
  states: {}
- name: mmse_resampler_xx_0_1_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 192000/44100
    type: float
  states: {}
- name: mmse_resampler_xx_0_1_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 192000/44100
    type: float
  states: {}
- name: mmse_resampler_xx_0_1_1
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 192000/44100
    type: float
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52004'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_0_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '10372'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_0_0_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '9952'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_0_0_0_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '6942'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_0_0_0_0_0_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '9392'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52002'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_1_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '10370'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_1_0_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '9950'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_1_1
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '6943'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_1_1_0_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '9391'
    type: TCP_SERVER
  states: {}
- name: nrsc5_hdc_encoder_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: '16000'
    channels: '2'
  states: {}
- name: nrsc5_hdc_encoder_0_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: '8000'
    channels: '2'
  states: {}
- name: nrsc5_hdc_encoder_0_0_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: '8000'
    channels: '2'
  states: {}
- name: nrsc5_hdc_encoder_0_0_0_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: '4000'
    channels: '2'
  states: {}
- name: nrsc5_hdc_encoder_0_0_0_0_0_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: '4000'
    channels: '2'
  states: {}
- name: nrsc5_l1_fm_encoder_mp3_0
  id: nrsc5_l1_fm_encoder_mp3
  parameters: {}
  states: {}
- name: nrsc5_l2_encoder_0
  id: nrsc5_l2_encoder
  parameters:
    data_bytes: '2000'
    first_prog: '0'
    num_progs: '5'
    size: '146176'
  states: {}
- name: nrsc5_lot_encoder_0
  id: nrsc5_lot_encoder
  parameters:
    filename: WDNRHDLogo.png
    lot_id: '42'
    port: '0x1003'
  states: {}
- name: nrsc5_lot_encoder_0_0
  id: nrsc5_lot_encoder
  parameters:
    filename: album_art.jpg
    lot_id: '1337'
    port: '0x1000'
  states: {}
- name: nrsc5_lot_encoder_0_0_0
  id: nrsc5_lot_encoder
  parameters:
    filename: album_art.jpg
    lot_id: '1338'
    port: '0x1002'
  states: {}
- name: nrsc5_lot_encoder_0_0_0_0
  id: nrsc5_lot_encoder
  parameters:
    filename: album_art.jpg
    lot_id: '1339'
    port: '0x1004'
  states: {}
- name: nrsc5_lot_encoder_0_0_0_0_0
  id: nrsc5_lot_encoder
  parameters:
    filename: album_art.jpg
    lot_id: '1339'
    port: '0x1006'
  states: {}
- name: nrsc5_lot_encoder_0_0_0_0_0_0_0
  id: nrsc5_lot_encoder
  parameters:
    filename: album_art.jpg
    lot_id: '1339'
    port: '0x1008'
  states: {}
- name: nrsc5_lot_encoder_0_1
  id: nrsc5_lot_encoder
  parameters:
    filename: WXKJHDLogo.png
    lot_id: '43'
    port: '0x1001'
  states: {}
- name: nrsc5_lot_encoder_0_1_0
  id: nrsc5_lot_encoder
  parameters:
    filename: WDUSHDLogo.png
    lot_id: '43'
    port: '0x1005'
  states: {}
- name: nrsc5_lot_encoder_0_1_0_0
  id: nrsc5_lot_encoder
  parameters:
    filename: SmartFMHDLogo.png
    lot_id: '44'
    port: '0x1007'
  states: {}
- name: nrsc5_lot_encoder_0_1_0_0_0_0
  id: nrsc5_lot_encoder
  parameters:
    filename: WPSZHDLogo.png
    lot_id: '44'
    port: '0x1009'
  states: {}
- name: nrsc5_psd_encoder_0
  id: nrsc5_psd_encoder
  parameters:
    artist: 106 WDNR
    bytes_per_frame: '128'
    prog_num: '1'
    title: Hampton Roads Best Rock & Variety
  states: {}
- name: nrsc5_psd_encoder_0_0
  id: nrsc5_psd_encoder
  parameters:
    artist: 103.7 KISS FM
    bytes_per_frame: '128'
    prog_num: '0'
    title: 'Hampton Roads #1 Hit Music Station'
  states: {}
- name: nrsc5_psd_encoder_0_0_0
  id: nrsc5_psd_encoder
  parameters:
    artist: US99
    bytes_per_frame: '128'
    prog_num: '2'
    title: 'Newport News #1 For New Country'
  states: {}
- name: nrsc5_psd_encoder_0_1
  id: nrsc5_psd_encoder
  parameters:
    artist: SmartFM
    bytes_per_frame: '128'
    prog_num: '3'
    title: The Best 80's Hits, Halloween Music and Christmas Music!
  states: {}
- name: nrsc5_psd_encoder_0_1_0_0
  id: nrsc5_psd_encoder
  parameters:
    artist: News Radio 93.9 FM / 750 AM WPSZ
    bytes_per_frame: '128'
    prog_num: '4'
    title: Hampton Roads Trusted News Leader
  states: {}
- name: nrsc5_sis_encoder_0
  id: nrsc5_sis_encoder
  parameters:
    altitude: '17.0'
    country_code: US
    fcc_facility_id: '0'
    latitude: '36.9165'
    longitude: '-76.2146'
    message: Check us out online at kissfmva.com
    mode: nrsc5.pids_mode.FM
    num_programs: '5'
    program0: nrsc5.program_type.TOP_40
    program1: nrsc5.program_type.ROCK
    program2: nrsc5.program_type.COUNTRY
    program3: nrsc5.program_type.NOSTALGIA
    program4: nrsc5.program_type.TALK
    program5: nrsc5.program_type.NEWS
    program6: nrsc5.program_type.NEWS
    program7: nrsc5.program_type.NEWS
    short_name: 1037 KISS -FM
    slogan: 'Hampton Roads #1 Hit Music Station'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    freq0: freq
    gain0: '0'
    if_gain0: '99999'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '49'
    interp: '125'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '500000'
    interp: '1000000'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_1_1
  id: rational_resampler_xxx
  parameters:
    decim: '384'
    interp: '2000'
    taps: ''
    type: ccf
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '243'
    interp: '256'
    taps: ''
    type: ccc
  states: {}

connections:
- [audio_source_0_0, '0', mmse_resampler_xx_0_1, '0']
- [audio_source_0_0, '1', mmse_resampler_xx_0_0_0, '0']
- [audio_source_0_0_0, '0', mmse_resampler_xx_0_1_1, '0']
- [audio_source_0_0_0, '1', mmse_resampler_xx_0_0_0_1, '0']
- [audio_source_0_0_0_0, '0', mmse_resampler_xx_0_1_0, '0']
- [audio_source_0_0_0_0, '1', mmse_resampler_xx_0_0_0_0, '0']
- [audio_source_0_0_0_0_0_0, '0', mmse_resampler_xx_0_1_0_0, '0']
- [audio_source_0_0_0_0_0_0, '1', mmse_resampler_xx_0_0_0_0_0, '0']
- [audio_source_0_0_1, '0', mmse_resampler_xx_0, '0']
- [audio_source_0_0_1, '1', mmse_resampler_xx_0_0, '0']
- [audio_source_1, '0', blocks_delay_0, '0']
- [audio_source_1_0, '0', blocks_add_xx_1, '1']
- [blocks_add_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_add_xx_1, '0', gr_frequency_modulator_fc_0_0, '0']
- [blocks_conjugate_cc_0, '0', rational_resampler_xxx_1, '0']
- [blocks_delay_0, '0', blocks_add_xx_1, '0']
- [blocks_keep_m_in_n_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_null_source_0, '0', nrsc5_l1_fm_encoder_mp3_0, '1']
- [blocks_repeat_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_keep_m_in_n_0, '0']
- [fft_vxx_0, '0', blocks_repeat_0, '0']
- [gr_frequency_modulator_fc_0_0, '0', rational_resampler_xxx_1_1_1, '0']
- [mmse_resampler_xx_0, '0', nrsc5_hdc_encoder_0, '0']
- [mmse_resampler_xx_0_0, '0', nrsc5_hdc_encoder_0, '1']
- [mmse_resampler_xx_0_0_0, '0', nrsc5_hdc_encoder_0_0, '1']
- [mmse_resampler_xx_0_0_0_0, '0', nrsc5_hdc_encoder_0_0_0_0, '1']
- [mmse_resampler_xx_0_0_0_0_0, '0', nrsc5_hdc_encoder_0_0_0_0_0_0, '1']
- [mmse_resampler_xx_0_0_0_1, '0', nrsc5_hdc_encoder_0_0_0, '1']
- [mmse_resampler_xx_0_1, '0', nrsc5_hdc_encoder_0_0, '0']
- [mmse_resampler_xx_0_1_0, '0', nrsc5_hdc_encoder_0_0_0_0, '0']
- [mmse_resampler_xx_0_1_0_0, '0', nrsc5_hdc_encoder_0_0_0_0_0_0, '0']
- [mmse_resampler_xx_0_1_1, '0', nrsc5_hdc_encoder_0_0_0, '0']
- [network_socket_pdu_0, pdus, nrsc5_lot_encoder_0_0, file]
- [network_socket_pdu_0_0, pdus, nrsc5_lot_encoder_0_0_0, file]
- [network_socket_pdu_0_0_0, pdus, nrsc5_lot_encoder_0_0_0_0, file]
- [network_socket_pdu_0_0_0_0, pdus, nrsc5_lot_encoder_0_0_0_0_0, file]
- [network_socket_pdu_0_0_0_0_0_0, pdus, nrsc5_lot_encoder_0_0_0_0_0_0_0, file]
- [network_socket_pdu_1, pdus, nrsc5_psd_encoder_0, set_meta]
- [network_socket_pdu_1_0, pdus, nrsc5_psd_encoder_0_0, set_meta]
- [network_socket_pdu_1_0_0, pdus, nrsc5_psd_encoder_0_0_0, set_meta]
- [network_socket_pdu_1_1, pdus, nrsc5_psd_encoder_0_1, set_meta]
- [network_socket_pdu_1_1_0_0, pdus, nrsc5_psd_encoder_0_1_0_0, set_meta]
- [nrsc5_hdc_encoder_0, '0', nrsc5_l2_encoder_0, '0']
- [nrsc5_hdc_encoder_0_0, '0', nrsc5_l2_encoder_0, '2']
- [nrsc5_hdc_encoder_0_0_0, '0', nrsc5_l2_encoder_0, '1']
- [nrsc5_hdc_encoder_0_0_0_0, '0', nrsc5_l2_encoder_0, '3']
- [nrsc5_hdc_encoder_0_0_0_0_0_0, '0', nrsc5_l2_encoder_0, '4']
- [nrsc5_l1_fm_encoder_mp3_0, '0', fft_vxx_0, '0']
- [nrsc5_l1_fm_encoder_mp3_0, clock, nrsc5_psd_encoder_0, clock]
- [nrsc5_l1_fm_encoder_mp3_0, clock, nrsc5_psd_encoder_0_0, clock]
- [nrsc5_l1_fm_encoder_mp3_0, clock, nrsc5_psd_encoder_0_0_0, clock]
- [nrsc5_l1_fm_encoder_mp3_0, clock, nrsc5_psd_encoder_0_1, clock]
- [nrsc5_l1_fm_encoder_mp3_0, clock, nrsc5_psd_encoder_0_1_0_0, clock]
- [nrsc5_l2_encoder_0, '0', nrsc5_l1_fm_encoder_mp3_0, '0']
- [nrsc5_l2_encoder_0, ready, nrsc5_lot_encoder_0, ready]
- [nrsc5_l2_encoder_0, ready, nrsc5_lot_encoder_0_0, ready]
- [nrsc5_l2_encoder_0, ready, nrsc5_lot_encoder_0_0_0, ready]
- [nrsc5_l2_encoder_0, ready, nrsc5_lot_encoder_0_0_0_0, ready]
- [nrsc5_l2_encoder_0, ready, nrsc5_lot_encoder_0_0_0_0_0, ready]
- [nrsc5_l2_encoder_0, ready, nrsc5_lot_encoder_0_0_0_0_0_0_0, ready]
- [nrsc5_l2_encoder_0, ready, nrsc5_lot_encoder_0_1, ready]
- [nrsc5_l2_encoder_0, ready, nrsc5_lot_encoder_0_1_0, ready]
- [nrsc5_l2_encoder_0, ready, nrsc5_lot_encoder_0_1_0_0, ready]
- [nrsc5_l2_encoder_0, ready, nrsc5_lot_encoder_0_1_0_0_0_0, ready]
- [nrsc5_l2_encoder_0, ready, nrsc5_sis_encoder_0, ready]
- [nrsc5_lot_encoder_0, aas, nrsc5_l2_encoder_0, aas]
- [nrsc5_lot_encoder_0_0, aas, nrsc5_l2_encoder_0, aas]
- [nrsc5_lot_encoder_0_0_0, aas, nrsc5_l2_encoder_0, aas]
- [nrsc5_lot_encoder_0_0_0_0, aas, nrsc5_l2_encoder_0, aas]
- [nrsc5_lot_encoder_0_0_0_0_0, aas, nrsc5_l2_encoder_0, aas]
- [nrsc5_lot_encoder_0_0_0_0_0_0_0, aas, nrsc5_l2_encoder_0, aas]
- [nrsc5_lot_encoder_0_1, aas, nrsc5_l2_encoder_0, aas]
- [nrsc5_lot_encoder_0_1_0, aas, nrsc5_l2_encoder_0, aas]
- [nrsc5_lot_encoder_0_1_0_0, aas, nrsc5_l2_encoder_0, aas]
- [nrsc5_lot_encoder_0_1_0_0_0_0, aas, nrsc5_l2_encoder_0, aas]
- [nrsc5_psd_encoder_0, '0', nrsc5_l2_encoder_0, '6']
- [nrsc5_psd_encoder_0_0, '0', nrsc5_l2_encoder_0, '5']
- [nrsc5_psd_encoder_0_0_0, '0', nrsc5_l2_encoder_0, '7']
- [nrsc5_psd_encoder_0_1, '0', nrsc5_l2_encoder_0, '8']
- [nrsc5_psd_encoder_0_1_0_0, '0', nrsc5_l2_encoder_0, '9']
- [nrsc5_sis_encoder_0, '0', nrsc5_l1_fm_encoder_mp3_0, '2']
- [nrsc5_sis_encoder_0, aas, nrsc5_l2_encoder_0, aas]
- [rational_resampler_xxx_1, '0', rational_resampler_xxx_2, '0']
- [rational_resampler_xxx_1_1_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [rational_resampler_xxx_1_1_1, '0', rational_resampler_xxx_1_1_0, '0']
- [rational_resampler_xxx_2, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
