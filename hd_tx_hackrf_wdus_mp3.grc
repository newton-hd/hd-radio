options:
  parameters:
    generate_options: no_gui
    id: hd_tx_hackrf_wdus_mp3
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 99.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: pulse
    num_outputs: '2'
    samp_rate: '44100'
  states: {}
- name: audio_source_0_0
  id: audio_source
  parameters:
    device_name: pulse
    num_outputs: '2'
    samp_rate: '44100'
  states: {}
- name: audio_source_0_0_0
  id: audio_source
  parameters:
    device_name: pulse
    num_outputs: '2'
    samp_rate: '44100'
  states: {}
- name: audio_source_0_0_0_0
  id: audio_source
  parameters:
    device_name: pulse
    samp_rate: '44100'
  states: {}
- name: audio_source_0_0_0_0_0
  id: audio_source
  parameters:
    device_name: pulse
    samp_rate: '44100'
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '2160'
    n: '4096'
    offset: '0'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.025'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: complex
    vlen: '2048'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[math.sin(math.pi / 2 * i / 112) for i in range(112)] + [1] * (2048-112) + [math.cos(math.pi / 2 * i / 112) for i in range(112)]'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(2048)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: nrsc5_hdc_encoder_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: '24000'
    channels: '2'
  states: {}
- name: nrsc5_hdc_encoder_0_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: '12000'
    channels: '2'
  states: {}
- name: nrsc5_hdc_encoder_0_0_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: '12000'
    channels: '2'
  states: {}
- name: nrsc5_hdc_encoder_0_0_0_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: '8000'
    channels: '1'
  states: {}
- name: nrsc5_hdc_encoder_0_0_0_0_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: '4000'
    channels: '1'
  states: {}
- name: nrsc5_l1_fm_encoder_mp2_0
  id: nrsc5_l1_fm_encoder_mp2
  parameters: {}
  states: {}
- name: nrsc5_l2_encoder_0
  id: nrsc5_l2_encoder
  parameters:
    first_prog: '0'
    num_progs: '5'
    size: '146176'
  states: {}
- name: nrsc5_l2_encoder_1
  id: nrsc5_l2_encoder
  parameters:
    first_prog: '6'
    num_progs: '1'
    size: '2304'
  states: {}
- name: nrsc5_psd_encoder_0
  id: nrsc5_psd_encoder
  parameters:
    artist: US99
    prog_num: '0'
    title: 'Newport News #1 For New Country'
  states: {}
- name: nrsc5_psd_encoder_0_0
  id: nrsc5_psd_encoder
  parameters:
    artist: Lite Rock 92.1 WLRO
    prog_num: '1'
    title: Lite Rock... More Variety
  states: {}
- name: nrsc5_psd_encoder_0_0_0
  id: nrsc5_psd_encoder
  parameters:
    artist: HOT 89.9
    prog_num: '2'
    title: 'Norfolk''s #1 For Hip Hop and R&B'
  states: {}
- name: nrsc5_psd_encoder_0_0_0_0
  id: nrsc5_psd_encoder
  parameters:
    artist: Kat Kountry
    prog_num: '3'
    title: 'Myrtle Beach''s #1 For New Country'
  states: {}
- name: nrsc5_psd_encoder_0_0_0_0_0
  id: nrsc5_psd_encoder
  parameters:
    artist: News Radio 93.9 FM/750 AM WPSZ
    prog_num: '4'
    title: Hampton Roads News, Traffic & Weather
  states: {}
- name: nrsc5_sis_encoder_0
  id: nrsc5_sis_encoder
  parameters:
    short_name: WDUS
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '500000'
    freq0: freq
    gain0: '100'
    if_gain0: '100'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '49'
    interp: '125'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '243'
    interp: '256'
    taps: ''
    type: ccc
  states: {}

connections:
- [audio_source_0, '0', nrsc5_hdc_encoder_0, '0']
- [audio_source_0, '1', nrsc5_hdc_encoder_0, '1']
- [audio_source_0_0, '0', nrsc5_hdc_encoder_0_0, '0']
- [audio_source_0_0, '1', nrsc5_hdc_encoder_0_0, '1']
- [audio_source_0_0_0, '0', nrsc5_hdc_encoder_0_0_0, '0']
- [audio_source_0_0_0, '1', nrsc5_hdc_encoder_0_0_0, '1']
- [audio_source_0_0_0_0, '0', nrsc5_hdc_encoder_0_0_0_0, '0']
- [audio_source_0_0_0_0_0, '0', nrsc5_hdc_encoder_0_0_0_0_0, '0']
- [blocks_conjugate_cc_0, '0', rational_resampler_xxx_1, '0']
- [blocks_keep_m_in_n_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', osmosdr_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_null_source_0, '0', nrsc5_l2_encoder_1, '0']
- [blocks_null_source_0_0, '0', nrsc5_l2_encoder_1, '1']
- [blocks_repeat_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_keep_m_in_n_0, '0']
- [fft_vxx_0, '0', blocks_repeat_0, '0']
- [nrsc5_hdc_encoder_0, '0', nrsc5_l2_encoder_0, '0']
- [nrsc5_hdc_encoder_0_0, '0', nrsc5_l2_encoder_0, '1']
- [nrsc5_hdc_encoder_0_0_0, '0', nrsc5_l2_encoder_0, '2']
- [nrsc5_hdc_encoder_0_0_0_0, '0', nrsc5_l2_encoder_0, '3']
- [nrsc5_hdc_encoder_0_0_0_0_0, '0', nrsc5_l2_encoder_0, '4']
- [nrsc5_l1_fm_encoder_mp2_0, '0', fft_vxx_0, '0']
- [nrsc5_l2_encoder_0, '0', nrsc5_l1_fm_encoder_mp2_0, '0']
- [nrsc5_l2_encoder_1, '0', nrsc5_l1_fm_encoder_mp2_0, '1']
- [nrsc5_psd_encoder_0, '0', nrsc5_l2_encoder_0, '5']
- [nrsc5_psd_encoder_0_0, '0', nrsc5_l2_encoder_0, '6']
- [nrsc5_psd_encoder_0_0_0, '0', nrsc5_l2_encoder_0, '7']
- [nrsc5_psd_encoder_0_0_0_0, '0', nrsc5_l2_encoder_0, '8']
- [nrsc5_psd_encoder_0_0_0_0_0, '0', nrsc5_l2_encoder_0, '9']
- [nrsc5_sis_encoder_0, '0', nrsc5_l1_fm_encoder_mp2_0, '2']
- [rational_resampler_xxx_1, '0', rational_resampler_xxx_2, '0']
- [rational_resampler_xxx_2, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
