options:
  parameters:
    generate_options: no_gui
    id: foxxo
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '192000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: 192000* 4
    tau: '75e-6'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '14780'
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/wavc.wav
    repeat: 'True'
    type: float
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '11000'
    freq0: '106500000'
    gain0: '11000'
    if_gain0: '11000'
    sample_rate: '2000000'
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_tx_0, '0', osmosdr_sink_0, '0']
- [blocks_delay_0, '0', analog_wfm_tx_0, '0']
- [blocks_file_source_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
