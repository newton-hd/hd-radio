options:
  parameters:
    category: RDS
    generate_options: no_gui
    id: rds_tx
    output_language: python
  states: {}

blocks:
- name: fm_max_dev
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 103.7e6
  states: {}
- name: input_gain
  id: variable
  parameters:
    value: '0.26'
  states: {}
- name: outbuffer
  id: variable
  parameters:
    value: '0'
  states: {}
- name: pilot_gain
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: rds_gain
  id: variable
  parameters:
    value: 4000 / fm_max_dev
  states: {}
- name: rds_gain_0
  id: variable
  parameters:
    value: '0.3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: 38e3*20
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    num_outputs: '2'
    ok_to_block: 'False'
    samp_rate: '88200'
  states: {}
- name: audio_source_0_0
  id: audio_source
  parameters:
    num_outputs: '2'
    samp_rate: '88200'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '2160'
    n: '4096'
    offset: '0'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.015'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: complex
    vlen: '2048'
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '10372'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '10371'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[math.sin(math.pi / 2 * i / 112) for i in range(112)] + [1] * (2048-112) + [math.cos(math.pi / 2 * i / 112) for i in range(112)]'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(2048)
  states: {}
- name: gr_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: gr_add_xx_1
  id: blocks_add_xx
  parameters:
    maxoutbuf: outbuffer
    num_inputs: '3'
    type: float
  states: {}
- name: gr_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    maxoutbuf: outbuffer
    sensitivity: '1.32278'
  states: {}
- name: gr_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: gr_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 38e3
    offset: '0'
    phase: '0'
    samp_rate: usrp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: gr_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: pilot_gain
    freq: 19e3
    offset: '0'
    phase: '0'
    samp_rate: usrp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: gr_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: input_gain
    interp: '1'
    samp_rate: usrp_rate
    type: interp_fir_filter_fff
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: input_gain
    interp: '1'
    samp_rate: usrp_rate
    type: interp_fir_filter_fff
    width: 2e3
    win: firdes.WIN_HAMMING
  states: {}
- name: nrsc5_hdc_encoder_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: '64000'
    channels: '2'
  states: {}
- name: nrsc5_l1_fm_encoder_mp1_0
  id: nrsc5_l1_fm_encoder_mp1
  parameters: {}
  states: {}
- name: nrsc5_l2_encoder_0
  id: nrsc5_l2_encoder
  parameters:
    first_prog: '0'
    num_progs: '1'
    size: '146176'
  states: {}
- name: nrsc5_psd_encoder_0
  id: nrsc5_psd_encoder
  parameters:
    artist: Artist
    prog_num: '0'
    title: Title
  states: {}
- name: nrsc5_sis_encoder_0
  id: nrsc5_sis_encoder
  parameters:
    short_name: KISS
  states: {}
- name: osmosdr_sink_0_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    freq0: freq
    gain0: '0'
    if_gain0: '100000000'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '380'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '380'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '38'
    interp: '100'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '49'
    interp: '125'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '243'
    interp: '256'
    taps: ''
    type: ccc
  states: {}

connections:
- [audio_source_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '1', rational_resampler_xxx_0_0, '0']
- [audio_source_0_0, '0', nrsc5_hdc_encoder_0, '0']
- [audio_source_0_0, '1', nrsc5_hdc_encoder_0, '1']
- [blocks_add_xx_0, '0', osmosdr_sink_0_0, '0']
- [blocks_conjugate_cc_0, '0', rational_resampler_xxx_1_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_repeat_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_socket_pdu_0_0, pdus, nrsc5_psd_encoder_0, title in]
- [blocks_socket_pdu_0_0_0, pdus, nrsc5_psd_encoder_0, artist in]
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_keep_m_in_n_0, '0']
- [fft_vxx_0, '0', blocks_repeat_0, '0']
- [gr_add_xx_0, '0', low_pass_filter_0_0, '0']
- [gr_add_xx_1, '0', gr_frequency_modulator_fc_0, '0']
- [gr_frequency_modulator_fc_0, '0', rational_resampler_xxx_1, '0']
- [gr_multiply_xx_1, '0', gr_add_xx_1, '2']
- [gr_sig_source_x_0, '0', gr_multiply_xx_1, '0']
- [gr_sig_source_x_0_1, '0', gr_add_xx_1, '1']
- [gr_sub_xx_0, '0', low_pass_filter_0_0_0, '0']
- [low_pass_filter_0_0, '0', gr_add_xx_1, '0']
- [low_pass_filter_0_0_0, '0', gr_multiply_xx_1, '1']
- [nrsc5_hdc_encoder_0, '0', nrsc5_l2_encoder_0, '0']
- [nrsc5_l1_fm_encoder_mp1_0, '0', fft_vxx_0, '0']
- [nrsc5_l2_encoder_0, '0', nrsc5_l1_fm_encoder_mp1_0, '0']
- [nrsc5_psd_encoder_0, '0', nrsc5_l2_encoder_0, '1']
- [nrsc5_sis_encoder_0, '0', nrsc5_l1_fm_encoder_mp1_0, '1']
- [rational_resampler_xxx_0, '0', gr_add_xx_0, '0']
- [rational_resampler_xxx_0, '0', gr_sub_xx_0, '0']
- [rational_resampler_xxx_0_0, '0', gr_add_xx_0, '1']
- [rational_resampler_xxx_0_0, '0', gr_sub_xx_0, '1']
- [rational_resampler_xxx_1, '0', blocks_add_xx_0, '1']
- [rational_resampler_xxx_1_0, '0', rational_resampler_xxx_2, '0']
- [rational_resampler_xxx_2, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
