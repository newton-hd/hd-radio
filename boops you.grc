options:
  parameters:
    generate_options: no_gui
    id: boopsyou
    output_language: python
    title: Boops
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 99.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: audio_rate
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    freq0: freq
    gain0: '0'
    if_gain0: '999999999'
    sample_rate: '2000000'
    sync: sync
    type: fc32
  states: {}

connections:
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
